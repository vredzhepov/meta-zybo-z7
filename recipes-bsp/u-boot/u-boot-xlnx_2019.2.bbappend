FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

UBOOTURI = "git://github.com/vredzhepov/u-boot-xlnx.git;protocol=https"
