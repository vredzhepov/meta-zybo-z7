FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

KERNELURI = "git://github.com/vredzhepov/linux-xlnx.git;protocol=https"
